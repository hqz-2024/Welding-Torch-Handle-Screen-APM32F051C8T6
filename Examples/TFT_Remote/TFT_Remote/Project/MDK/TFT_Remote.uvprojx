# Keil uVision project TFT_Remote.uvprojx, settings and files
target APM32F030 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32F051C8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TFT_Remote +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F030_MINI,APM32F030x8
  c include: ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Boards;..\..\Include;..\..\HARDWARE\LCD;..\..\HARDWARE\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f030.s startup_apm32f051.s startup_apm32f072.s startup_apm32f091.s
  group StdPeriphLib
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group Board
    ../../../../../Boards/: Board.c
  group Application
    ../../Source/: main.c bys_comm.c apm32f0xx_int.c
    ../../HARDWARE/LCD/: lcd.c lcd_init.c
target APM32F051 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F051R8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: as above
  output: TFT_Remote
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F051_MINI,APM32F051x8
  c include: ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Boards;..\..\Include;..\..\HARDWARE\LCD;..\..\HARDWARE\LCD;..\..\HARDWARE\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target APM32F072 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F072VB Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TFT_Remote
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F072_MINI,APM32F072xB
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target APM32F091 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F091VC Geehy
  pack: Geehy.APM32F0xx_DFP.1.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TFT_Remote
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F091_MINI,APM32F091xC
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
